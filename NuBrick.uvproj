# Keil uVision project NuBrick.uvproj, settings and files
target NuBrick (ARM-ADS)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: NuBrick
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 wLevel=2
  c define: M451
  c include: ..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\Library\StdDriver\inc;.\include;..\AHRSLib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ./: main.c timerctrl.c i2cdev.c flash.c nvti2c.c scheduler.c buzzer.c gas.c hostcommand.c ir.c led.c sonar.c temperature.c wirecommand.c report.c Calibrate.c MPU6050.c sensors.c ahrs.c battery.c PWM1P1_IRQ.c PWM0P2_IRQ.c timer3IRQ.c timer1IRQ.c
  group Library
    ../../../Library/StdDriver/src/: gpio.c i2c.c pwm.c timer.c sys.c uart.c clk.c fmc.c spi.c eadc.c
    ../AHRSLib/obj/: AHRSLibM4.lib
    ./: retarget.c
  group Include
    ./: timerctrl.h def.h config.h flash.h i2cdev.h nvti2c.h scheduler.h battery.h buzzer.h gas.h hostcommand.h ir.h led.h sonar.h temperature.h wirecommand.h report.h Calibrate.h MPU6050.h retarget.h sensors.h ahrs.h PWM1P1_IRQ.h PWM0P2_IRQ.h timer3IRQ.h timer1IRQ.h
    ../AHRSLib/include/: AHRSLib.h
